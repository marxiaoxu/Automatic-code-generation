# Keil uVision project bishe.uvprojx, settings and files
target bishe (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: bishe +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o  C:\Users\Administrator\Desktop\bishe\MDK-ARM\bishe\bishe.bin  C:\Users\Administrator\Desktop\bishe\MDK-ARM\bishe\bishe.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: MEM_UNIT_BYTES,ARM_MATH_CM4,MemUnit_T=uint8_T,MATLAB_PROJECT,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                                      ../Drivers/STM32F4xx_HAL_Driver/Inc;                                      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                      ../Drivers/CMSIS/Include;                                      ../Drivers/CMSIS/Core/Include;                                      ../Drivers/CMSIS/DSP/Include;                                      ../xusiming/Inc;                                      D:/matlab2022a/simulink/include;                                      ../../../../../MATLAB/STM32-MAT/STM32/addSrc/inc;                                      ../../../../../MATLAB/STM32-MAT/STM32/addSrc/R2018b/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group MATLAB
    C:/Users/Administrator/Desktop/bishe/xusiming/Src/: xusiming_data.c rtGetInf.c rtGetNaN.c rt_nonfinite.c rt_zcfcn.c xusiming.c xusiming_CAN.c xusiming_TIM.c xusiming_USART.c
    C:/MATLAB/STM32-MAT/STM32/addSrc/src/: getBuffPtr.c
software components: CMSIS:CORE 5.4.0
